# Repository MU-3D-Printing-Club/2020

File README.md:

# 2020
Meetings 2pm Thursday in E3508.

[Link to Ada Assembly instructions](https://openbionicslabs.com/obtutorials/ada-v1-assembly)

## Updates 2/27/2020
- Please remember to always **PULL FROM ORIGIN** and make a new branch before you make edits.
- Installed gitHub, Eagle, and SolidWorks on lab computer

## V2
Stuart's ARM board and probably Rust code.
- [x] Ask Dr. Gillis for review. (JD)
- [ ] Get rust code running for servos on discovery board. PWM libraries and also [potentiometer controlled feedback](https://www.actuonix.com/Actuonix-PQ-12-P-Linear-Actuator-p/pq12-p.htm). (Chris/Jake/Stuart/James/Matt)
- [x] Identify which rust-compatible chip to buy. (Jake/Stuart)
## V1
### V1.3 

Added [boost regulator](http://ww1.microchip.com/downloads/en/DeviceDoc/20005572A.pdf) in addition to 1.2 changes.  
- [ ] Review Ahmad's suggestions. Look in "Regulator" branch. (Jake/Ethan)
- [ ] Make Vcc route bigger.
### V1.2
Added [LiPo](https://cdn.sparkfun.com/assets/learn_tutorials/6/9/5/MCP738312.pdf) charger.

- [ ] Solder chip and resistors on.
- [ ] Burn bootloader and code. See if it works.
- [ ] Research new trigger algorithm. (James/Matt)
- [ ] Research custom myoelectric sensor. (Rosie)
- [ ] PALM DESIGN! (Chris, Hannah, Colm)
### V1.1
Reorganized PCB. Larger back cover.

- [ ] Document
- [ ] SHIP.
- [x] Tie knots. (Jack)
- [x] Solder myoelectric in.
- [x] Attach servos.
- [x] Print back cover.
- [x] Epoxy screw in.
- [x] Get the programmer out of reset mode. (Stuart)

### V1.0
From December. Broke because of lack and space/organization in back cover.

## V0
Bare bones code and prototype back cover. Cannot find Eagle file. Only legend speaks of this.

<pre>
.
├── Datasheets
│   ├── Actuonix+PQ12+Datasheet.pdf
│   ├── MCP73831.pdf
│   └── STM32F303.pdf
├── Myosensor
│   ├── Myosense.v1.brd
│   └── Myosense.v1.sch
├── Old
│   ├── Eagle Libraries
│   │   └── 3DPC.lbr
│   ├── Jig Components
│   │   ├── Legiment Jig.SLDPRT
│   │   └── Legiment Jig.STL
│   ├── eletronics test bed
│   │   ├── 400 point breadboard holder.stl
│   │   ├── STM32F3DISCOVERY holder.stl
│   │   ├── actuonix PQ12 servo holder.stl
│   │   ├── battery holder.stl
│   │   └── electronics v1.0 holder.stl
│   ├── v0.0
│   │   ├── SolidWorks
│   │   │   ├── Backcover 12-6-19.SLDPRT
│   │   │   └── Backcover 12-6-19.STL
│   │   ├── myoFlex-Original
│   │   │   └── myoFlex.ino
│   │   └── pcb
│   │       ├── circuitdraft.brd
│   │       ├── circuitdraft.sch
│   │       └── eagle.epf
│   ├── v0.1
│   │   └── PCB
│   │       ├── circuitdraft.brd
│   │       ├── circuitdraft.sch
│   │       └── eagle.epf
│   ├── v1.0
│   │   ├── PCB
│   │   │   ├── circuitdraft.brd
│   │   │   ├── circuitdraft.sch
│   │   │   └── eagle.epf
│   │   ├── PCB Libraries
│   │   │   ├── SamacSys_Parts.lbr
│   │   │   ├── TPS54627DDAR.lbr
│   │   │   ├── charger.lbr
│   │   │   ├── ind2.lbr
│   │   │   ├── inductor.lbr
│   │   │   ├── mega32U4.lbr
│   │   │   ├── microchip-update.lbr
│   │   │   └── powerPad.lbr
│   │   ├── SolidWorks
│   │   │   ├── 191216_Backcover_JD.SLDPRT
│   │   │   └── 191216_Backcover_JD.STL
│   │   ├── circuitdraft.txt
│   │   └── mainCode
│   │       └── mainCode.ino
│   ├── v1.1
│   │   ├── CAD
│   │   │   ├── 02_18_2020_BackcoverC.SLDPRT
│   │   │   ├── 02_18_2020_BackcoverF.SLDPRT
│   │   │   ├── 02_18_2020_BackcoverF.STL
│   │   │   ├── 2020_03_02_BackcoverShell.SLDPRT
│   │   │   ├── 203101_Backcover.SLDPRT
│   │   │   ├── Front Face Palm Screen Capture.PNG
│   │   │   ├── New Palm STL.STL
│   │   │   ├── New Palm.SLDPRT
│   │   │   ├── R_palm.SLDPRT
│   │   │   └── R_palm.stl
│   │   ├── Code
│   │   │   ├── Blink
│   │   │   │   └── Blink.ino
│   │   │   ├── helloWorld
│   │   │   │   └── helloWorld.ino
│   │   │   ├── mainCode
│   │   │   │   └── mainCode.ino
│   │   │   └── servoTest
│   │   │       └── servoTest.ino
│   │   └── PCB
│   │       ├── circuitdraft.brd
│   │       ├── circuitdraft.sch
│   │       └── eagle.epf
│   ├── v1.2
│   │   ├── Notes.txt
│   │   ├── PCB
│   │   │   ├── circuitdraft.brd
│   │   │   ├── circuitdraft.sch
│   │   │   └── eagle.epf
│   │   ├── mainCode
│   │   │   └── mainCode.ino
│   │   └── testLiPoCharger
│   │       └── testLiPoCharger.ino
│   ├── v1.3
│   │   ├── circuitdraft.brd
│   │   └── circuitdraft.sch
│   ├── v2.0
│   │   └── PCB
│   │       ├── Hand v2.0 parts.lib
│   │       ├── Hand v2.0-cache.lib
│   │       ├── Hand v2.0-rescue.dcm
│   │       ├── Hand v2.0.kicad_pcb
│   │       ├── Hand v2.0.kicad_pcb-bak
│   │       ├── Hand v2.0.net
│   │       ├── Hand v2.0.sch
│   │       ├── Hand v2.0.sch-bak
│   │       ├── fp-info-cache
│   │       ├── hand parts.bck
│   │       ├── hand parts.dcm
│   │       └── sym-lib-table
│   └── v2.1
│       └── PCB
│           ├── 2020-02-01_02-22-13
│           │   ├── 2020-02-01_02-22-13.lib
│           │   ├── footprints.pretty
│           │   │   └── STM32F302_303C2.kicad_mod
│           │   └── readme.txt
│           ├── Hand v2.1 parts.lib
│           ├── Hand v2.1-cache.lib
│           ├── Hand v2.1-rescue.dcm
│           ├── Hand v2.1-rescue.lib
│           ├── Hand v2.1.kicad_pcb
│           ├── Hand v2.1.kicad_pcb-bak
│           ├── Hand v2.1.net
│           ├── Hand v2.1.sch
│           ├── Hand v2.1.sch-bak
│           ├── fp-info-cache
│           ├── hand parts.bck
│           ├── hand parts.dcm
│           └── sym-lib-table
├── README.md
├── tree.txt
├── treeCMD.txt
└── v3.0
    └── hand v3.0
        ├── Hand Parts.bck
        ├── Hand Parts.dcm
        ├── Hand Parts.lib
        ├── fp-info-cache
        ├── hand v3.0-cache.lib
        ├── hand v3.0.kicad_pcb
        ├── hand v3.0.sch
        ├── hand v3.0.sch-bak
        ├── hand v3.xml
        └── sym-lib-table

38 directories, 103 files

</pre>
tree -I "*.pro|*.b#?|*.s#?|*.l?|*.job" -o tree.txt

## KiCad design v2.1/PCB/Hand v2.1.kicad_pcb

Parts:
BT1: Battery_Cell; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
BTN1: Side_Button; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
C1, C3, C13: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5, C11: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 4.7uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 22uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7, C8, C9, C10: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C12: 10nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CHRG1: MCP73831-2-OT; SOT-23-5
J1: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical
L1: 1uH 3A; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
LED1: Charging_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
LED2: Charge_Done_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
M1: Index_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M2: Middle_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M3: Ring_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M4: Pinky_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M5: Thumb_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
MYO1: MyoWare; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
NEO1: Indicator_NeoPixel; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
R1: 2000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3: 470ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 1Mohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R8: 5000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R9: 1250ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 500ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
REG1: MIC5504-3.3YM5; SOT-23-5
REG2: MIC2876-5.0YMT-T5; DFN-8-1EP_2x2mm_P0.5mm_EP0.9x1.3mm
SW1: Power_Switch; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
U1: STM32F303CCT7; LQFP-48_7x7mm_P0.5mm
USB1: USB_B_Micro; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal

Connections:
+3V3: C3.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, J1.1 (VTref), MYO1.1 (Vs+), NEO1.3 (VDD), REG1.5 (VOUT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD)
+5V: C6.1, M1.2 (+), M2.2 (+), M3.2 (+), M4.2 (+), M5.2 (+), REG2.5 (WOUTS), REG2.8 (OUT)
+BATT: C1.1, C4.1, L1.2, R4.1, R5.1, REG1.1 (VIN), REG1.3 (EN), REG2.3 (IN), REG2.6 (EN), SW1.2 (B)
BTN: BTN1.1, U1.29 (PA8)
GND: BT1.2 (-), BTN1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), LED2.1 (K), M1.3 (-), M2.3 (-), M3.3 (-), M4.3 (-), M5.3 (-), MYO1.2 (GND), NEO1.2 (GND), R4.2, R6.2, R9.2, REG1.2 (GND), REG2.2 (PGND), REG2.4 (AGND), REG2.7 (/PG), REG2.9 (EP), U1.2 (PC13), U1.3 (PC14), U1.4 (PC15), U1.5 (PF0), U1.6 (PF1), U1.8 (VSSA), U1.18 (PB0), U1.19 (PB1), U1.20 (PB2), U1.21 (PB10), U1.22 (PB11), U1.23 (VSS), U1.25 (PB12), U1.26 (PB13), U1.27 (PB14), U1.28 (PB15), U1.30 (PA9), U1.31 (PA10), U1.32 (PA11), U1.33 (PA12), U1.35 (VSS), U1.38 (PA15), U1.39 (PB3), U1.40 (PB4), U1.41 (PB5), U1.42 (PB6), U1.43 (PB7), U1.44 (BOOT0), U1.45 (PB8), U1.46 (PB9), U1.47 (VSS), USB1.5 (GND), USB1.6 (Shield); also elsewhere on the board
INDEX: M1.1 (PWM), U1.10 (PA0)
MIDDLE: M2.1 (PWM), U1.11 (PA1)
MYOSIG: MYO1.3 (SIG), R8.1
NEO: R7.2, U1.17 (PA7)
NORMMYOSIG: R8.2, R9.1, U1.14 (PA4)
NORMVBAT: R5.2, R6.1, U1.15 (PA5)
unnamed 11: BT1.1 (+), C5.1, CHRG1.3 (VBAT), SW1.1 (A); also elsewhere on the board
unnamed: C2.1, CHRG1.4 (VDD), LED1.2 (A), USB1.1 (VBUS)
unnamed: CHRG1.1 (STAT), R2.1, R3.1
unnamed: CHRG1.2 (VSS), R1.2
unnamed: CHRG1.5 (PROG), R1.1
unnamed: J1.2 (SWDIO/TMS), U1.34 (PA13)
unnamed: J1.4 (SWDCLK/TCK), U1.37 (PA14)
unnamed: J1.10 (~RESET~), U1.7 (NRST)
unnamed: L1.1, REG2.1 (SW)
unnamed: LED1.1 (K), R2.2
unnamed: LED2.2 (A), R3.2
unnamed: NEO1.4 (DIN), R7.1
PINKY: M4.1 (PWM), U1.13 (PA3)
RING: M3.1 (PWM), U1.12 (PA2)
THUMB: M5.1 (PWM), U1.16 (PA6)

Board: 2 copper layers, 39.0 x 58.0 mm, 40 parts (5 on the bottom side), 26 nets.

Other parts of the board:
BATT1: Battery_Cell; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal

Their connections:
GND: BATT1.2; also elsewhere on the board
unnamed 11: BATT1.1; also elsewhere on the board

## KiCad design v2.0/PCB/Hand v2.0.kicad_pcb

Parts:
BT1: Battery_Cell; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
BTN1: Side_Button; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
C1, C3: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5: 4.7uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 4.7uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6: 22uF 10V; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
CHRG1: MCP73831-2-OT; SOT-23-5
J1: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical
L1: 1uH 3A; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
LED1: Charging_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
LED2: Charge_Done_LED; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
M1: Index_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M2: Middle_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M3: Ring_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M4: Pinky_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
M5: Thumb_Servo; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
MCU1: ATSAMD11C14A-SS; SOIC-14_3.9x8.7mm_P1.27mm
MYO1: MyoWare; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
NEO1: Indicator_NeoPixel; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
R1: 2000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3: 470ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4: 1Mohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R8: 5000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R9: 1250ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7: 500ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R10: 1000ohm; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
REG1: MIC5504-3.3YM5; SOT-23-5
REG2: MIC2876-5.0YMT-T5; DFN-8-1EP_2x2mm_P0.5mm_EP0.9x1.3mm
SW1: Power_Switch; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
USB1: USB_B_Micro; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal

Connections:
+3V3: C3.1, J1.1 (VTref), MCU1.12, MYO1.1 (Vs+), NEO1.3 (VDD), R10.1, REG1.5 (VOUT)
+5V: C6.1, M1.2 (+), M2.2 (+), M3.2 (+), M4.2 (+), M5.2 (+), REG2.5 (WOUTS), REG2.8 (OUT)
+BATT: C1.1, C4.1, L1.2, R4.1, R5.1, REG1.1 (VIN), REG2.3 (IN), SW1.2 (B)
BTN: BTN1.1, MCU1.2
GND: BT1.2 (-), BTN1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), LED2.1 (K), M1.3 (-), M2.3 (-), M3.3 (-), M4.3 (-), M5.3 (-), MCU1.11, MYO1.2 (GND), NEO1.2 (GND), R6.2, R9.2, REG1.2 (GND), REG2.2 (PGND), REG2.4 (AGND), REG2.9 (EP), USB1.5 (GND), USB1.6 (Shield)
INDEX: M1.1 (PWM), MCU1.4
MIDDLE: M2.1 (PWM), MCU1.5
MYOSIG: MYO1.3 (SIG), R8.1
NEO: MCU1.3, R7.2
NORMMYOSIG: MCU1.13, R8.2, R9.1
NORMVBAT: MCU1.1, R5.2, R6.1
unnamed: BT1.1 (+), C5.1, CHRG1.3 (VBAT), SW1.1 (A)
unnamed: C2.1, CHRG1.4 (VDD), LED1.2 (A), USB1.1 (VBUS)
unnamed: CHRG1.1 (STAT), R2.1, R3.1
unnamed: CHRG1.2 (VSS), R1.2
unnamed: CHRG1.5 (PROG), R1.1
unnamed: J1.2 (SWDIO/TMS), MCU1.8
unnamed: J1.4 (SWDCLK/TCK), MCU1.7, R10.2
unnamed: J1.10 (~RESET~), MCU1.6
unnamed: L1.1, REG2.1 (SW)
unnamed: LED1.1 (K), R2.2
unnamed: LED2.2 (A), R3.2
unnamed: NEO1.4 (DIN), R7.1
unnamed: R4.2, REG2.7 (/PG)
PINKY: M4.1 (PWM), MCU1.10
RING: M3.1 (PWM), MCU1.9
THUMB: M5.1 (PWM), MCU1.14

Board: 2 copper layers, 39.0 x 58.0 mm, 35 parts (6 on the bottom side), 27 nets.

## Code that names these connections

File v1.1/Code/mainCode/mainCode.ino (part):

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Servo pointer;
Servo middle;
Servo ring;
Servo pinky;

#define extendmin 2000    //static integers of extendminimum and extendmaximum servo extension
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
enum pins
{
  THUMB_PIN = 9,
  INDEX_PIN = 5,
  MIDDLE_PIN = 6,
  RING_PIN = 3,
  PINKY_PIN = 10,
  VBAT_PIN = A0,
  MYO_PIN = A5,
  LED_PIN = 11,
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  Serial1.begin(9600);     // starts up serial communication between arduino and computer

  Serial1.println("linking servos");
  thumb.attach(THUMB_PIN, extendmin, extendmax);    //defines where the servos are and their extendmax/extendmins
  pointer.attach(INDEX_PIN, extendmin, extendmax);
  middle.attach(MIDDLE_PIN, extendmin, extendmax);
  ring.attach(RING_PIN, extendmin, extendmax);
  pinky.attach(PINKY_PIN, extendmin, extendmax);

  pinMode(BUTTON_PIN, INPUT_PULLUP);
  attachInterrupt(digitalPinToInterrupt(BUTTON_PIN), locked, FALLING);
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  pointer.writeMicroseconds(pointerPos);
  middle.writeMicroseconds(middlePos);
  ring.writeMicroseconds(ringPos);
  pinky.writeMicroseconds(pinkyPos);
  delay(200);
  thumb.writeMicroseconds(thumbPos+150); //this is because the thumb is not tied tight
  delay(1000);       //this is so the servos have time to get to their set position
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  pointer.writeMicroseconds(pointer.readMicroseconds());
  middle.writeMicroseconds(middle.readMicroseconds());
  ring.writeMicroseconds(ring.readMicroseconds());
  pinky.writeMicroseconds(pinky.readMicroseconds());
  delay(250);
}

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
## Commit log

2020-01-25 Reorganized
2020-01-25 Added old files
2020-01-25 Set theme jekyll-theme-minimal
2020-01-25 renamed directories added v0.1 pcb
2020-01-25 added v1.1 and v2.0 boards
2020-01-25 added version silkscreen to v1.1 board
2020-01-25 v1.1 shifted silkscreen text
2020-01-25 v2.0 added version silkscreen and renamed files
2020-01-26 Add microchip eagle library
2020-01-26 Began creatin custom libraries
    Sorry chris for pushing directly to master. I will stop doin gthis now
2020-01-27 v2.0 fixed file naming issues
2020-01-31 readded v1.2 because oops
2020-02-01 Added switch. Passes DRC
    Final 1.2
2020-02-01 Update 191216_Backcover_JD.SLDPRT
    Added 5mm of height to exterior wall.
2020-02-01 Added jack's cover
    hope this works
2020-02-01 Added palm .stl
2020-02-01 Renamed Folder SolidWorks
2020-02-01 Update Readme. Rename Backover
2020-02-01 hi chris
2020-02-01 began swapping arm chips
2020-02-01 rename 2.0 to 2.1 for chip change
2020-02-01 undo oops by readding v2.0
2020-02-01 created servo holder for test bed
2020-02-02 finished adding STM32F303VCT6
2020-02-02 cleaned up silkscreen and updated version on silkscreen
2020-02-03 Removed Back Shell
2020-02-03 refined test bed mounts
2020-02-04 removed need for supports and made discovery board holder shorter and shifted holes
2020-02-04 Added code to 1.2
2020-02-05 Update eagle library
2020-02-05 Added MIC to Lib
2020-02-06 I wrote a test messge
2020-02-06 pooppoo
2020-02-06 Added MIC regulator
2020-02-09 connected unused IO pins on MCU to ground
2020-02-18 Create blink
2020-02-20 Added solid parts
2020-02-20 Updated 2_18_2020_F back cover
2020-02-20 Saved R_Palm file to a SLDPRT file
2020-02-20 Started moving timing chip
2020-02-21 Started ahmad's changes
2020-02-23 Created a SLDPRT file to manipulte in Blender. Foundation of new plam.
2020-02-27 New Palm has been updated
2020-02-27 restored files
2020-02-29 code
2020-03-01 Easier to print
2020-03-03 Jacks changes
2020-03-03 fix thumb pin
2020-03-03 added reset pull-up resistor
2020-03-03 zone refill
2020-03-07 new palm
2020-03-08 enabled regulators and removed unneeded part
2020-03-08 updated name of battery to be clearer
2020-03-09 Added dimensions for servo inlets in the new palm design
2020-03-12 Changed so servo does not grab so far
2020-03-18 test
2020-03-18 Added LM358
2020-04-11 added file tree
2020-04-12 Schematic1
2020-04-13 Worked on myosensor
2020-04-29 Myosensor board and library change
2020-05-21 Updated myosensor
2020-05-31 created v3 project
2020-06-03 testing 1.2 charger
2020-06-04 Added datasheets
2020-06-05 started on power for 3.0
2020-06-06 motor and motor drivers configured
2020-06-17 Housekeeping
2020-06-17 housekeeping part II
2020-06-29 added some datasheets
2020-06-30 Added some documents
2020-07-07 added bookmark
2020-08-13 added manual
2020-09-17 added bom
